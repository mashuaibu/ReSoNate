# Keil uVision project Project.uvprojx, settings and files
target STM32F411E-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411E-Discovery
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F411E_DISCO,CORTEX_M4,ARM_MATH_CM4,__EMBEDDED__,TIMER,__FPU_USED=1,__FPU_PRESENT=1
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/STM32F4xx_HAL_Driver/inc;../Drivers/BSP/STM32F411E-Discovery;..\codec2\src;..\codec2\stm32\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Include;..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: main.c audio_record.c audio_play.c stm32f4xx_it.c stm32f4_timer.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Middlewares/STM32_Audio
    ../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Drivers/BSP/STM32F411E-Discovery
    ../Drivers/BSP/STM32F411E-Discovery/: stm32f411e_discovery_audio.c stm32f411e_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c
  group codec2
    ../codec2/src/: fifo.c codec2.c lpc.c nlp.c postfilter.c sine.c kiss_fft.c interp.c lsp.c phase.c quantise.c pack.c codebook.c codebookd.c codebookge.c codebookjvm.c codec2_fft.c
  group CMSIS/DSP
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q7.c arm_conv_opt_q15.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q7.c arm_conv_partial_opt_q15.c arm_conv_partial_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_q7.c arm_conv_q15.c arm_conv_q31.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q7.c arm_correlate_opt_q15.c arm_correlate_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q7.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q7.c arm_fir_q15.c arm_fir_q31.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q7.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
    ../codec2/stm32/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c arm_bitreversal2.S
